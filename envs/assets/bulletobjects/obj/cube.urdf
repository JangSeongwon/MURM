Commit message: Update cube.urdf

File: envs/assets/bulletobjects/obj/cube.urdf (robot description, URDF)
Before this commit: robot cube.urdf, 1 links, 0 joints
Links:
- link cube: mass 0.1 -> 0.05
